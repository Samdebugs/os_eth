## meta-os_eth/conf/bblayers.conf
```bitbake
BBLAYERS ?= " \\
  /path/to/poky/meta \\
  /path/to/poky/meta-poky \\
  /path/to/poky/meta-yocto-bsp \\
  /path/to/meta-os_eth \\
  "
```
